
TOOLCHAIN_TARGET_TASK += " erlang-modules erlang-staticdev fwup"
TOOLCHAIN_HOST_TASK += " nativesdk-erlang nativesdk-elixir nativesdk-fwup"